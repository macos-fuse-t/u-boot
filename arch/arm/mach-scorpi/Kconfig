## arch/arm/mach-scorpi/Kconfig
```kconfig
if ARCH_SCORPI

config SYS_VENDOR
	default "emulation"

config SYS_BOARD
	default "scorpi-arm"

config SYS_CONFIG_NAME
	default "scorpi-arm64"

endif
```
